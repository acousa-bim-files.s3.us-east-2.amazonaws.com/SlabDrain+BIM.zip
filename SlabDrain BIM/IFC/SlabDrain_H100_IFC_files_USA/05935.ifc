Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 3902f0af-d73a-409b-ac8b-b986f36c0c24, VersionGUID: b0e2b204-28a2-46ab-a214-310e5e8e66e4, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 05935.ifc
Time: 2026-08-11T16:37:18+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.30.11 (ENU) - IFC 24.3.30.11

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcFlowTerminal: ZZZ_do not use_PF_ST_slabdrain_H100_endcaps_USA_ACO:std(nested), ZZZ_do not use_PF_ST_slabdrain_H100_endcaps_USA_ACO:std(nested):455217
In: Level 1
Type - Description: ACO Slabdrain_Endcaps; PredefinedType: USERDEFINED; Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
SlabDrain H100 Schedule - RSen_C_code_article: 05935; RSen_C_description: H100-8 Closing End Cap; RSen_S_net_mass: 0.3 kg; URL: www.acousa.com; productrange: Slabdrain; Manufacturer: ACO; Model: Slabdrain_Endcaps; OmniClass Title: Rainwater Removal; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_info_commercial: https://acoswm.com/drain/slabdrain/hk-series/
