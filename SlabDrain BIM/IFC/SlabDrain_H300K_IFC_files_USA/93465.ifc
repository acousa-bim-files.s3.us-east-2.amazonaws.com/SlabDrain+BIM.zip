Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 3902f0af-d73a-409b-ac8b-b986f36c0c24, VersionGUID: b0e2b204-28a2-46ab-a214-310e5e8e66e4, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 93465.ifc
Time: 2026-08-11T15:06:52+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.30.11 (ENU) - IFC 24.3.30.11

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcDistributionPort, OutPort_393383_1
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: PF_ST_Slabdrain_H300K & H300KS_channels_USA_ACO:H300KS-13 Constant Depth Channel with SS edge rail, PF_ST_Slabdrain_H300K & H300KS_channels_USA_ACO:H300KS-13 Constant Depth Channel with SS edge rail:393383
In: Level 1
Type - Description: ACO SlabDrain HK series channels; PredefinedType: USERDEFINED; Material: polymer concrete, Steel, Stainless
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: H300KS-13 Constant Depth Channel with SS edge rail; sets with these values: 2
SlabDrain H300K/H300KS Schedule - RSen_C_code_article: 93465; RSen_C_description: H300KS-13 Constant Depth Channel - 39.37" (1 m); RSen_S_net_mass: 32.47 kg; URL: www.acousa.com; productrange: SlabDrain; Manufacturer: ACO; Model: ACO SlabDrain HK series channels; OmniClass Title: Rainwater Removal; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_info_commercial: https://www.acousa.com/products/categories/stormwater-management/commercial-trench-drains/shallow-depth-drains/

# IfcFlowTerminal: ZZZ_do not use_PF_ST_H300K_gratings_USA_ACO:std(nested), ZZZ_do not use_PF_ST_H300K_gratings_USA_ACO:std(nested):393385
In: Level 1
Type - Description: ACO Grating for SlabDrain H300K; Material: Steel, Galvanised
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
SlabDrain H300K/H300KS Schedule - RSen_C_code_article: 98967; RSen_C_description: Type 811Q Galvanized perforated (1 m); RSen_S_net_mass: 14.01 kg; URL: www.acousa.com; productrange: SlabDrain; Manufacturer: ACO; Model: Grating for SlabDrain H300K; OmniClass Title: Rainwater Removal; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/

# IfcOpeningElement: Opening, PF_ST_Slabdrain_H300K & H300KS_channels_USA_ACO:H300KS-13 Constant Depth Channel with SS edge rail:393383:1
In: Level 1
Pset_OpeningElementCommon - Reference: H300KS-13 Constant Depth Channel with SS edge rail; sets with these values: 2
SlabDrain H300K/H300KS Schedule - RSen_C_code_article: 93465; RSen_C_description: H300KS-13 Constant Depth Channel - 39.37" (1 m); RSen_S_net_mass: 32.47 kg; URL: www.acousa.com; productrange: SlabDrain; Manufacturer: ACO; Model: ACO SlabDrain HK series channels; OmniClass Title: Rainwater Removal; RSen_C_content_creator: ACO Technology Centre, INDIA; RSen_C_info_commercial: https://www.acousa.com/products/categories/stormwater-management/commercial-trench-drains/shallow-depth-drains/
