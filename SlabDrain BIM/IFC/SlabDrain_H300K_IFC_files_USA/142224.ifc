Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c957132d-d893-4df5-9a47-bf16a8dcddbf, VersionGUID: f0fabcf1-b683-44b2-98bf-d9595ac98fc5, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 142224.ifc
Time: 2026-07-28T14:50:21+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.30.11 (ENU) - IFC 24.3.30.11

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcFlowTerminal: ZZZ_do not use_PF_ST_H300K_gratings_USA_ACO:std(nested) (2)
In: Level 1
Type - Description: ACO Grating for SlabDrain H300K; Material: Steel, Stainless
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
SlabDrain H300K/H300KS Gratings Schedule - RSen_C_code_article: 142224; RSen_C_description: Type 848D Stainless longitudinal (0.5 m); RSen_S_net_mass: 6.35 kg; URL: www.acousa.com; Manufacturer: ACO; productrange: SlabDrain; Model: Grating for SlabDrain H300K; OmniClass Title: Rainwater Removal; RSen_C_info_commercial: https://acoswm.com/drain/klassikdrain/; RSen_C_info_technical: https://acoswm.com/drain/klassikdrain/; RSen_C_content_creator: ACO Technology Centre, INDIA
Name (ZZZ_do not use_PF_ST_H300K_gratings_USA_ACO:std(nested):...)
385107
388735
