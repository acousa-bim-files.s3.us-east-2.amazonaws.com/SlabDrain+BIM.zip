Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c957132d-d893-4df5-9a47-bf16a8dcddbf, VersionGUID: f0fabcf1-b683-44b2-98bf-d9595ac98fc5, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 142219.ifc
Time: 2026-07-28T14:16:07+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.30.11 (ENU) - IFC 24.3.30.11

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcFlowTerminal: ZZZ_do not use_PF_ST_H200K_gratings_USA_ACO:std(nested), ZZZ_do not use_PF_ST_H200K_gratings_USA_ACO:std(nested):372751
In: Level 1
Type - Description: ACO Grating for SlabDrain H200K; PredefinedType: USERDEFINED; Material: Steel, Stainless
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
SlabDrain H200K/H200KS Gratings Schedule - RSen_C_code_article: 142219; RSen_C_description: Type 647D Stainless longitudinal; RSen_S_net_mass: 8.16 kg; URL: www.acousa.com; Manufacturer: ACO; productrange: SlabDrain; Model: Grating for SlabDrain H200K; OmniClass Title: Rainwater Removal; RSen_C_info_commercial: https://www.acousa.com/products/categories/stormwater-management/commercial-trench-drains/shallow-depth-drains/; RSen_C_info_technical: https://www.acousa.com/products/categories/stormwater-management/commercial-trench-drains/shallow-depth-drains/; RSen_C_content_creator: ACO Technology Centre, INDIA
