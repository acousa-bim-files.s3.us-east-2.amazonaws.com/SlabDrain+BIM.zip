Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: c68b7c68-165b-4818-961f-93ae58857a70, VersionGUID: b583d8cf-e452-4a03-86bc-7e30a5934726, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 99591.ifc
Time: 2026-05-27T16:22:49+05:30
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.30.11 (ENU) - IFC 24.3.30.11

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 in

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (in)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 157.48

# IfcFlowTerminal: ZZZ_do not use_PF_ST_S200K_gratings_USA_ACO:std(nested), ZZZ_do not use_PF_ST_S200K_gratings_USA_ACO:std(nested):500573
In: Level 1
Type - Description: ACO Grating for PowerDrain S200K; PredefinedType: USERDEFINED; Material: Iron, Ductile
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACO
Pset_DistributionFlowElementCommon - Reference: std(nested); sets with these values: 2
PowerDrain S200K Schedule - RSen_C_code_article: 99591; RSen_C_description: SK2 Ductile iron 4-bolt grate - 19.69" (0.5 m) (Load Class F); RSen_S_net_mass: 11.97 kg; productrange: PowerDrain; Model: Grating for PowerDrain S200K; URL: www.acousa.com; Manufacturer: ACO; RSen_C_content_creator: ACO Technology Centre, INDIA; LOD: LOD 300; RSen_C_info_technical: https://www.acousa.com/products/stormwater-management/commercial-trench-drains/heavy-duty-drains/powerdrain-s200k/; OmniClass Title: Rainwater Removal
